# Keil uVision project Pro.uvproj, settings and files
target pro (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: Pro
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\system\inc;..\hardware\inc
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c
